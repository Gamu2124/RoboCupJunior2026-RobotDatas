# Repository Gamu2124/RoboCupJunior2026-RobotDatas

## KiCad design Circuit/WorldChampionship/ball_RP2350/ball_2026_v1.kicad_pcb

Parts:
A1, A2, A3, A4, A5, A6, A7, A8, A9, A10, A11, A12, A13, A14, A15, A16, A17, A18, A19, A20, A21, A22, A23, A24: TSSP4038; XDCR_TSSP4038; PARTREV 2.3
C1, C4, C16: 4.7; C_0402_1005Metric
C2, C5, C6, C7, C8, C9, C11, C12, C14, C15: 0.1; C_0402_1005Metric
C3: 4.7; C_0402_1005Metric; LCSC C1872
C10, C13: 15p; C_0402_1005Metric; LCSC C1548
C17: 150; CP_Elec_6.3x5.7; LCSC C249851
D1: BLUE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D2: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2, J3: Conn_02x02_Counter_Clockwise; PinHeader_2x02_P2.54mm_Vertical
L1: 3.3; Inductor_0806_2016; LCSC C42411119
R1: 15; R_0402_1005Metric; LCSC C22369173
R2: 30; R_0402_1005Metric; LCSC C22356186
R3: 1k; R_0402_1005Metric; LCSC C174178
R4: 33; R_0603_1608Metric; LCSC C177281
R6: 22; R_0402_1005Metric; LCSC C174144
R7: 22; R_0402_1005Metric
U1: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
U2: RP2350_60QFN; Package_QFN-60-1EP_7x7mm_P0.4mm_EP3.4x3.4mm_hand
Y1: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C20625731

Connections:
+1V1: C1.1, C2.1, C4.1, C5.1, L1.1, U2.6 (DVDD), U2.23 (DVDD), U2.39 (DVDD), U2.50 (VREG_FB)
+3.3V: A1.3 (VS), A2.3 (VS), A3.3 (VS), A4.3 (VS), A5.3 (VS), A6.3 (VS), A7.3 (VS), A8.3 (VS), A9.3 (VS), A10.3 (VS), A11.3 (VS), A12.3 (VS), A13.3 (VS), A14.3 (VS), A15.3 (VS), A16.3 (VS), A17.3 (VS), A18.3 (VS), A19.3 (VS), A20.3 (VS), A21.3 (VS), A22.3 (VS), A23.3 (VS), A24.3 (VS), C6.1, C7.1, C8.1, C9.1, C11.1, C12.1, C14.1, C15.1, C16.1, C17.1, J2.1, J2.2, R4.1, U1.8 (VCC), U2.1 (IOVDD), U2.11 (IOVDD), U2.20 (IOVDD), U2.30 (IOVDD), U2.38 (IOVDD), U2.44 (ADC_AVDD), U2.45 (IOVDD), U2.49 (VREG_VIN), U2.53 (USB_OTP_VDD), U2.54 (QSPI_IOVDD)
/GPIO_0: U2.2 (GPIO0)
/QSPI_SCLK: U1.6 (CLK), U2.56 (QSPI_SCLK)
/QSPI_SD0: U1.5 (DI/IO_{0}), U2.57 (QSPI_SD0)
/QSPI_SD1: U1.2 (DO/IO_{1}), U2.59 (QSPI_SD1)
/QSPI_SD2: U1.3 (~WP/IO_{2}), U2.58 (QSPI_SD2)
/QSPI_SD3: U1.7 (~HOLD/~RESET/IO_{3}), U2.55 (QSPI_SD3)
/QSPI_SS: R3.2, U1.1 (~CS), U2.60 (QSPI_SS)
/SWCLK: U2.24 (SWCLK)
/SWD: U2.25 (SWD)
/VREG_AVDD: C3.1, R4.2, U2.46 (VREG_AVDD)
/VREG_LX: L1.2, U2.48 (VREG_LX)
/XIN: C10.1, U2.21 (XIN), Y1.1
/XOUT: C13.1, U2.22 (XOUT), Y1.3
B_0: A1.1 (OUT), U2.19 (GPIO15)
B_1: A2.1 (OUT), U2.27 (GPIO16)
B_2: A3.1 (OUT), U2.28 (GPIO17)
B_3: A4.1 (OUT), U2.29 (GPIO18)
B_4: A5.1 (OUT), U2.31 (GPIO19)
B_5: A6.1 (OUT), U2.32 (GPIO20)
B_6: A7.1 (OUT), U2.33 (GPIO21)
B_7: A8.1 (OUT), U2.34 (GPIO22)
B_8: A9.1 (OUT), U2.35 (GPIO23)
B_9: A10.1 (OUT), U2.40 (GPIO26_ADC0)
B_10: A11.1 (OUT), U2.41 (GPIO27_ADC1)
B_11: A12.1 (OUT), U2.42 (GPIO28_ADC2)
B_12: A13.1 (OUT), U2.43 (GPIO29_ADC3)
B_13: A14.1 (OUT), U2.4 (GPIO2)
B_14: A15.1 (OUT), U2.5 (GPIO3)
B_15: A16.1 (OUT), U2.9 (GPIO6)
B_16: A17.1 (OUT), U2.10 (GPIO7)
B_17: A18.1 (OUT), U2.12 (GPIO8)
B_18: A19.1 (OUT), U2.13 (GPIO9)
B_19: A20.1 (OUT), U2.14 (GPIO10)
B_20: A21.1 (OUT), U2.15 (GPIO11)
B_21: A22.1 (OUT), U2.16 (GPIO12)
B_22: A23.1 (OUT), U2.17 (GPIO13)
B_23: A24.1 (OUT), U2.18 (GPIO14)
DEBUG_LED: R2.1, U2.36 (GPIO24)
DEFAULT_LED: R1.1, U2.37 (GPIO25)
GND: A1.2 (GND), A2.2 (GND), A3.2 (GND), A4.2 (GND), A5.2 (GND), A6.2 (GND), A7.2 (GND), A8.2 (GND), A9.2 (GND), A10.2 (GND), A11.2 (GND), A12.2 (GND), A13.2 (GND), A14.2 (GND), A15.2 (GND), A16.2 (GND), A17.2 (GND), A18.2 (GND), A19.2 (GND), A20.2 (GND), A21.2 (GND), A22.2 (GND), A23.2 (GND), A24.2 (GND), C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, D1.1 (K), D2.1 (K), J2.3, J2.4, U1.4 (GND), U2.47 (VREG_PGND), U2.61 (GND), Y1.2, Y1.4
MCU_RUN: J3.3, U2.26 (RUN)
unnamed: D1.2 (A), R1.2
unnamed: D2.2 (A), R2.2
unnamed: R7.1, U2.51 (USB_DM)
unnamed: R6.1, U2.52 (USB_DP)
USB_BOOT: J1.4, R3.1
USB_D+: J1.2, R6.2
USB_D-: J1.1, R7.2
mainRX→rpTX: J3.1, U2.7 (GPIO4)
mainTX→rpRX: J3.2, U2.8 (GPIO5)

Notes on the sheet:
POWER
ABM8-272-T3
FLASH
CRYSTAL
MCU RP2350
DEBUG
FUNCTION
BALL_SENSOR
TSSP4038
抵抗はMCU近く
POWER_ON

Board: 2 copper layers, 150.0 x 150.0 mm, 56 parts (2 on the bottom side), 49 nets.

File Circuit/WorldChampionship/ball_RP2350/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"A1, A10, A11, A12, A13, A14, A15, A16, A17, A18, A19, A2, A20, A21, A22, A23, A24, A3, A4, A5, A6, A7, A8, A9",XDCR_TSSP4038,24,TSSP4038,
"C1, C16, C4",0402,3,4.7,
"C10, C13",0402,2,15p,C1548
"C11, C12, C14, C15, C2, C5, C6, C7, C8, C9",0402,10,0.1,
C17,CP_Elec_6.3x5.7,1,150,C249851
C3,0402,1,4.7,C1872
D1,0603,1,BLUE,
D2,0603,1,GREEN,
"J1, J2, J3",PinHeader_2x02_P2.54mm_Vertical,3,Conn_02x02_Counter_Clockwise,
L1,Inductor_0806_2016,1,3.3,C42411119
R1,0402,1,15,C22369173
R2,0402,1,30,C22356186
R3,0402,1,1k,C174178
R4,0603,1,33,C177281
R6,0402,1,22,C174144
R7,0402,1,22,
U1,SOIC-8_5.23x5.23mm_P1.27mm,1,W25Q128JVS,
U2,Package_QFN-60-1EP_7x7mm_P0.4mm_EP3.4x3.4mm_hand,1,RP2350_60QFN,
Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,Crystal_GND24,C20625731

## KiCad design Circuit/WorldChampionship/dcdc/dcdc_2026_v1.kicad_pcb

Parts:
C1, C7: 0.1; Capacitor_0402_1005
C2: 22; CP_Elec_5x5.4; LCSC C2887274
C3, C4, C9, C10, C11: 22; CP_Elec_5x5.4
C5: 10; CP_Elec_4x5.4; LCSC C2992602
C6: 2.7; CP_Elec_5x5.7
C8: 0.1; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C12: 10; CP_Elec_4x5.4
C13: 2.7; CP_Elec_5x5.7; LCSC C487141
D1: D; D_SOD-123F
F1: Fuse; Fuseholder_Clip-5x20mm_Keystone_3517_Inline_P23.11x6.76mm_D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
J1: oled; PinSocket_1x02_P2.54mm_Vertical
J2: md; AMASS_XT30U-M_1x02_P5.0mm_Vertical
J3: Conn_01x03_Socket; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
J4: md_logic; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J5: line; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J6: kick; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
L1: 3.3; L_Bourns_SRP7028A_7.3x6.6mm
L2: 4.7; IND_ETQP5M4R7YFM
LiPo_1: XT30_IN; AMASS_XT30U-M_1x02_P5.0mm_Vertical
Q1: PMOS; TO-252-2
R1: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R2: 69.8k; R_0805_2012Metric; LCSC C17803
R3: 10.5k; R_0402_1005Metric; LCSC C25850
R4: 200k; R_0805_2012Metric; LCSC C17539
R5: 22.1k; R_0805_2012Metric
R6: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; LCSC C26033
R7: 150k; R_0603_1608Metric; LCSC C177617
R8: 3.3k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal; LCSC C26033
R9: 22k; R_0805_2012Metric
R10: 200k; R_0805_2012Metric
R11: 22.1k; R_0805_2012Metric; LCSC C17552
RV1: 50k; Potentiometer_Bourns_3314J_Vertical
SW1: SW_SPST; PinSocket_1x02_P2.54mm_Vertical
U1: AP64500SP-3.3v; SO-8EP_DIO
U2: AP64500SP-7v; SO-8EP_DIO

Connections:
+3.3V: C2.1, C3.1, C4.1, J4.1, J4.2, J5.1, L1.2, R2.2
GND: C2.2, C3.2, C4.2, C5.2, C6.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, J1.1, J2.1, J3.2, J5.2, J6.2, LiPo_1.1 (-), R4.2, R5.1, R8.2, R10.2, R11.1, SW1.1 (A), U1.7 (GND), U1.EPAD (GND), U2.7 (GND), U2.EPAD (GND)
unnamed: C6.1, R3.1
unnamed: C13.1, R9.1
unnamed: D1.1 (K), F1.2, Q1.3 (S), R1.1
unnamed: F1.1, LiPo_1.2 (+)
unnamed: Q1.1 (G), R1.2, SW1.2 (B)
unnamed: R7.1, RV1.1
unnamed: C1.1, U1.1 (BST)
unnamed: R3.2, U1.6 (COMP)
unnamed: R2.1, R5.2, U1.5 (FB)
unnamed: R4.1, U1.4 (RT/CLK)
unnamed: C1.2, L1.1, U1.8 (SW)
unnamed: C7.1, U2.1 (BST)
unnamed: R9.2, U2.6 (COMP)
unnamed: R11.2, RV1.2, RV1.3, U2.5 (FB)
unnamed: R10.1, U2.4 (RT/CLK)
unnamed: C7.2, L2.1, U2.8 (SW)
VCC: C5.1, C12.1, D1.2 (A), J1.2, J2.2, J6.1, Q1.2 (D), R6.1, U1.2 (VIN), U1.3 (EN), U2.2 (VIN), U2.3 (EN)
VOUT: C8.1, J3.3, R6.2, R8.1

Notes on the sheet:
POWER_DISTRIBUTION

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
Board: 2 copper layers, 76.1 x 45.5 mm, 43 parts (2 on the bottom side), 21 nets.

Other parts of the board:
H1, H1#2: MountingHole; MountingHole_3.2mm_M3
SW: rocker_SW; Rocker_SW

File Circuit/WorldChampionship/dcdc/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C7",Capacitor_0402_1005,2,0.1,
"C10, C11, C3, C4, C9",CP_Elec_5x5.4,5,22,
C12,CP_Elec_4x5.4,1,10,
C13,CP_Elec_5x5.7,1,2.7,C487141
C2,CP_Elec_5x5.4,1,22,C2887274
C5,CP_Elec_4x5.4,1,10,C2992602
C6,CP_Elec_5x5.7,1,2.7,
C8,0603,1,0.1,
D1,D_SOD-123F,1,D,
F1,Fuseholder_Clip-5x20mm_Keystone_3517_Inline_P23.11x6.76mm_D1.70mm_Horizontal,1,Fuse,
J1,PinSocket_1x02_P2.54mm_Vertical,1,oled,
J2,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,md,
J3,JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,1,Conn_01x03_Socket,
J4,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,md_logic,
J5,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,line,
J6,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,kick,
L1,L_Bourns_SRP7028A_7.3x6.6mm,1,3.3,
L2,IND_ETQP5M4R7YFM,1,4.7,
LIPO_1,AMASS_XT30U-M_1x02_P5.0mm_Vertical,1,XT30_IN,
Q1,TO-252-2,1,PMOS,
R1,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,1,10k,
R10,0805,1,200k,
R11,0805,1,22.1k,C17552
R2,0805,1,69.8k,C17803
R3,0402,1,10.5k,C25850
R4,0805,1,200k,C17539
R5,0805,1,22.1k,
R6,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,1,10k,C26033
R7,0603,1,150k,C177617
R8,R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal,1,3.3k,C26033
R9,0805,1,22k,
RV1,Potentiometer_Bourns_3314J_Vertical,1,50k,
SW,Rocker_SW,1,rocker_SW,
SW1,PinSocket_1x02_P2.54mm_Vertical,1,SW_SPST,
U1,SO-8EP_DIO,1,AP64500SP-3.3v,
U2,SO-8EP_DIO,1,AP64500SP-7v,

## KiCad design Circuit/WorldChampionship/drv8432/drv8432_V3.kicad_pcb

Board: 2 copper layers, 17.7 x 33.7 mm, 14 parts (1 on the bottom side), 17 nets.

Parts:
C1, C4, C5, C6, C7: 0.1u; C_0603_1608Metric
C2: 220u; C_Elec_8x10.2
C3: 1u; C_1206_3216Metric
D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
J1, J2: Conn_01x06_Pin; PinHeader_1x06_P2.54mm_Vertical
R1: 47k; R_0402_1005Metric
R2: 1; R_0603_1608Metric
R3: 25; R_0805_2012Metric
U1: DRV8432; HSOP-36-1EP_11.0x15.9mm_P0.65mm_SlugUp

Connections:
+3.3V: C1.1, J1.3, R3.1, U1.10 (VREG), U1.12 (M2), U1.13 (M1)
+12V: C2.1, C3.1, J1.1, U1.1 (GVDD_B), U1.17 (VDD), U1.18 (GVDD_C), U1.19 (GVDD_D), U1.21 (PVDD_D), U1.26 (PVDD_C), U1.29 (PVDD_B), U1.34 (PVDD_A), U1.36 (GVDD_A)
GND: C2.2, C3.2, D1.1 (K), J1.2, J2.1, R2.2, U1.6 (PWM_B), U1.8 (GND), U1.16 (PWM_D), U1.23 (GND_D), U1.24 (GND_C), U1.31 (GND_B), U1.32 (GND_A)
unnamed: D1.2 (A), R3.2
unnamed: C4.1, U1.35 (BST_A)
unnamed: C5.1, U1.28 (BST_B)
unnamed: C6.1, U1.27 (BST_C)
unnamed: C7.1, U1.20 (BST_D)
unnamed: R1.2, U1.7 (OC_ADJ)
OUT1_1: C4.2, J2.2, U1.33 (OUT_A)
OUT1_2: C5.2, J2.3, U1.30 (OUT_B)
OUT2_1: C6.2, J2.4, U1.25 (OUT_C)
OUT2_2: C7.2, J2.5, U1.22 (OUT_D)
PWM_1: J1.5, U1.4 (PWM_A)
PWM_2: J1.6, U1.14 (PWM_C)
RESET: J1.4, U1.5 (~RESET_AB), U1.15 (~RESET_CD)
VSS: C1.2, R1.1, R2.1, U1.9 (AGND), U1.11 (M3)

## KiCad design Circuit/WorldChampionship/kicker/kick_.kicad_pcb

Board: 2 copper layers, 76.1 x 45.5 mm, 26 parts (13 on the bottom side), 17 nets.

Parts:
D1: SBD; D_SOD-323_HandSoldering
D2: D; D_SOD-123F
D4: D; D_A-405_P10.16mm_Horizontal
H1, H1#2: MountingHole; MountingHole_3.2mm_M3
J1: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
J2, J3: Conn_01x02_Socket; PinSocket_1x02_P2.54mm_Vertical
J7, J8, J10, J11: Conn_01x01_Socket; PinSocket_1x01_P2.54mm_Vertical
K1: AQW212EHA; SMDIP-8_W7.62mm
LED_D1: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
Q1: PMOS; TO-252-2
Q2: NMOS; TO-220-3_Horizontal_TabDown
R1, R2: 1.6k; R_1206_3216Metric
R4: 1k; R_2512_6332Metric
R5: 3.3k; R_2512_6332Metric
R6: 150; R_2512_6332Metric
R9: 3k; R_2512_6332Metric
R10: 68; R_1206_3216Metric
R11: 10k; R_1206_3216Metric
main_1: Conn_01x03_Socket; JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal
sole1: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal

Connections:
+12V: J1.1, J7.1, K1.5
+48V: D1.2 (A), J10.1
GND: J1.2, J2.2, J3.2, J8.1, J11.1, K1.7, LED_D1.1 (K), Q2.3 (S), R11.1
GND_MAIN: K1.2, K1.4, main_1.1
unnamed: D1.1 (K), D2.2 (A), Q1.3 (S), R4.1
unnamed: D2.1 (K), Q1.2 (D), R6.1
unnamed: D4.2 (A), Q2.1 (D), sole1.2
unnamed: D4.1 (K), J2.1, J3.1, R6.2, R9.1, sole1.1
unnamed: K1.1, R1.2
unnamed: K1.3, R2.2
unnamed: K1.6, R10.1
unnamed: K1.8, R5.1
unnamed: LED_D1.2 (A), R9.2
unnamed: Q1.1 (G), R4.2, R5.2
unnamed: Q2.2 (G), R10.2, R11.2
kick_1: R1.1, main_1.3
kick_2: R2.1, main_1.2

File Circuit/WorldChampionship/kicker/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
D1,D_SOD-323_HandSoldering,1,SBD,
D2,D_SOD-123F,1,D,
D4,D_A-405_P10.16mm_Horizontal,1,D,
"J1, SOLE1",JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,2,Conn_01x02_Socket,
"J10, J11, J7, J8",PinSocket_1x01_P2.54mm_Vertical,4,Conn_01x01_Socket,
"J2, J3",PinSocket_1x02_P2.54mm_Vertical,2,Conn_01x02_Socket,
K1,SMDIP-8_W7.62mm,1,AQW212EHA,
LED_D1,0603,1,LED,
MAIN_1,JST_XH_S3B-XH-A_1x03_P2.50mm_Horizontal,1,Conn_01x03_Socket,
Q1,TO-252-2,1,PMOS,
Q2,TO-220-3_Horizontal_TabDown,1,NMOS,
R1,1206,1,1.6k,C4908
R10,1206,1,68,
R11,1206,1,10k,
R2,1206,1,1.6k,C102100 
R4,2512,1,1k,C31884
R5,2512,1,3.3k,C1469
R6,2512,1,150,C25471
R9,2512,1,3k,C2934109

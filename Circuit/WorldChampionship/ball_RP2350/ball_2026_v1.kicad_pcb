# Repository Gamu2124/RoboCupJunior2026-RobotDatas (continued)

## KiCad design Circuit/WorldChampionship/line_RP2350/line_2026_v1.kicad_pcb

Parts:
C1, C3, C4, C5, C6, C7, C8, C9, C10, C11, C12, C18: 0.1; C_0402_1005Metric
C2, C14, C15: 4.7; C_0402_1005Metric
C13: 4.7; C_0402_1005Metric; LCSC C1872
C16, C17: 15p; C_0402_1005Metric; LCSC C1548
C19: 100; CP_Elec_5x5.4
C20: 1u; C_Elec_4x5.4; LCSC C3348
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32, D35, D36, D37, D38, D41, D42, D43, D44, D47, D48, D49, D50: NJL; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D33: BLUE; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D34: GREEN; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64: SBD; D_SOD-323
J1: Conn_01x02_Socket; JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal
L1: 3.3; Inductor_0806_2016; LCSC C42411119
LED_1, LED_2, LED_3, LED_4, LED_5, LED_6, LED_7, LED_8, LED_9, LED_10, LED_11, LED_12, LED_13, LED_14, LED_15, LED_16, LED_17, LED_18, LED_19, LED_20, LED_21, LED_22, LED_23, LED_24, LED_25, LED_26, LED_27, LED_28, LED_29, LED_30, LED_31, LED_32, LED_33, LED_34, LED_35, LED_36, LED_39, LED_40, LED_41, LED_42, LED_45, LED_46, LED_47, LED_48: LED; LED_0603_1608Metric_Pad1.05x0.95mm_HandSolder
LINE1: TYPE-C_LINE; USB_C_Receptacle_XKB_U262-16XN-4BVC11; PARTREV B
Q1: AO3400A; SOT-23
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32, R92, R93, R94, R95, R98, R99, R100, R101, R104, R105, R106, R107: 69.8k; R_0603_1608Metric; LCSC C23098
R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64, R110, R111, R112, R113, R114, R115, R116, R117, R118, R119, R120, R121: 1k; R_0603_1608Metric; LCSC C23098
R65: 33; R_0603_1608Metric; LCSC C177281
R66: 22; R_0402_1005Metric; LCSC C174144
R67: 22; R_0402_1005Metric
R68: 1k; R_0402_1005Metric; LCSC C174178
R69: 15; R_0402_1005Metric; LCSC C22369173
R70: 30; R_0402_1005Metric; LCSC C22356186
R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86, R128, R129, R131, R132, R134, R135: 25; R_0603_1608Metric
R87: 220; R_0805_2012Metric
R88: 10k; R_0603_1608Metric
R89: 10k; R_0603_1608Metric; LCSC C23098
R90, R91: 5.1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder; LCSC C26033
U1, U2, U3, U4, U5, U6, U7, U8, U9, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U20, U21, U22: LM393; SOIC-8_3.9x4.9mm_P1.27mm
U25: RP2350B-QFN80; RP2350B_QFN-80_EP_10.573x10.573_Pitch0.4mm
U26: W25Q128JVS; SOIC-8_5.23x5.23mm_P1.27mm
Y1: Crystal_GND24; Crystal_SMD_3225-4Pin_3.2x2.5mm; LCSC C20625731
line_1: Conn_01x06_Socket; TE_84952-6_1x06-1MP_P1.0mm_Horizontal

Connections:
+1V1: C1.1, C2.1, C3.1, C15.1, L1.1, U25.10 (DVDD), U25.32 (DVDD), U25.51 (DVDD), U25.65 (VREG_FB)
+3.3V: C4.1, C5.1, C6.1, C7.1, C8.1, C9.1, C10.1, C11.1, C12.1, C14.1, C18.1, C19.1, D1.2 (A), D2.2 (A), D3.2 (A), D4.2 (A), D5.2 (A), D6.2 (A), D7.2 (A), D8.2 (A), D9.2 (A), D10.2 (A), D11.2 (A), D12.2 (A), D13.2 (A), D14.2 (A), D15.2 (A), D16.2 (A), D17.2 (A), D18.2 (A), D19.2 (A), D20.2 (A), D21.2 (A), D22.2 (A), D23.2 (A), D24.2 (A), D25.2 (A), D26.2 (A), D27.2 (A), D28.2 (A), D29.2 (A), D30.2 (A), D31.2 (A), D32.2 (A), D35.2 (A), D36.2 (A), D37.2 (A), D38.2 (A), D41.2 (A), D42.2 (A), D43.2 (A), D44.2 (A), D47.2 (A), D48.2 (A), D49.2 (A), D50.2 (A), J1.1, R33.2, R34.2, R35.2, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, R42.2, R43.2, R44.2, R45.2, R46.2, R47.2, R48.2, R49.2, R50.2, R51.2, R52.2, R53.2, R54.2, R55.2, R56.2, R57.2, R58.2, R59.2, R60.2, R61.2, R62.2, R63.2, R64.2, R65.1, R71.1, R72.1, R73.1, R74.1, R75.1, R76.1, R77.1, R78.1, R79.1, R80.1, R81.1, R82.1, R83.1, R84.1, R85.1, R86.1, R110.2, R111.2, R112.2, R113.2, R114.2, R115.2, R116.2, R117.2, R118.2, R119.2, R120.2, R121.2, R128.1, R129.1, R131.1, R132.1, R134.1, R135.1, U1.8 (V+), U2.8 (V+), U3.8 (V+), U4.8 (V+), U5.8 (V+), U6.8 (V+), U7.8 (V+), U8.8 (V+), U9.8 (V+), U10.8 (V+), U11.8 (V+), U12.8 (V+), U13.8 (V+), U14.8 (V+), U15.8 (V+), U16.8 (V+), U17.8 (V+), U18.8 (V+), U19.8 (V+), U20.8 (V+), U21.8 (V+), U22.8 (V+), U25.5 (IOVDD), U25.15 (IOVDD), U25.24 (IOVDD), U25.29 (IOVDD), U25.41 (IOVDD), U25.50 (IOVDD), U25.59 (ADC_AVDD), U25.60 (IOVDD), U25.64 (VREG_VIN), U25.68 (USB_OTP_VDD), U25.69 (QSPI_IOVDD), U25.76 (IOVDD), U26.8 (VCC)
/GPIO_0: U25.77 (GPIO0)
/Line_A0: D1.1 (K), R1.1, U1.5 (+)
/Line_A1: D2.1 (K), R2.1, U1.3 (+)
/Line_A2: D3.1 (K), R3.1, U2.5 (+)
/Line_A3: D4.1 (K), R4.1, U2.3 (+)
/Line_A4: D5.1 (K), R5.1, U3.5 (+)
/Line_A5: D6.1 (K), R6.1, U3.3 (+)
/Line_A6: D7.1 (K), R7.1, U4.5 (+)
/Line_A7: D8.1 (K), R8.1, U4.3 (+)
/Line_A8: D9.1 (K), R9.1, U5.5 (+)
/Line_A9: D10.1 (K), R10.1, U5.3 (+)
/Line_A10: D11.1 (K), R11.1, U6.5 (+)
/Line_A11: D12.1 (K), R12.1, U6.3 (+)
/Line_A12: D13.1 (K), R13.1, U7.5 (+)
/Line_A13: D14.1 (K), R14.1, U7.3 (+)
/Line_A14: D15.1 (K), R15.1, U8.5 (+)
/Line_A15: D16.1 (K), R16.1, U8.3 (+)
/Line_A16: D17.1 (K), R17.1, U9.5 (+)
/Line_A17: D18.1 (K), R18.1, U9.3 (+)
/Line_A18: D19.1 (K), R19.1, U10.5 (+)
/Line_A19: D20.1 (K), R20.1, U10.3 (+)
/Line_A20: D21.1 (K), R21.1, U11.5 (+)
/Line_A21: D22.1 (K), R22.1, U11.3 (+)
/Line_A22: D23.1 (K), R23.1, U12.5 (+)
/Line_A23: D24.1 (K), R24.1, U12.3 (+)
/Line_A24: D25.1 (K), R25.1, U13.5 (+)
/Line_A25: D26.1 (K), R26.1, U13.3 (+)
/Line_A26: D27.1 (K), R27.1, U14.5 (+)
/Line_A27: D28.1 (K), R28.1, U14.3 (+)
/Line_A28: D29.1 (K), R29.1, U15.5 (+)
/Line_A29: D30.1 (K), R30.1, U15.3 (+)
/Line_A30: D31.1 (K), R31.1, U16.5 (+)
/Line_A31: D32.1 (K), R32.1, U16.3 (+)
/QSPI_SCLK: U25.71 (QSPI_SCLK), U26.6 (CLK)
/QSPI_SD0: U25.72 (QSPI_SD0), U26.5 (DI/IO_{0})
/QSPI_SD1: U25.74 (QSPI_SD1), U26.2 (DO/IO_{1})
/QSPI_SD2: U25.73 (QSPI_SD2), U26.3 (~WP/IO_{2})
/QSPI_SD3: U25.70 (QSPI_SD3), U26.7 (~HOLD/~RESET/IO_{3})
/QSPI_SS: R68.2, U25.75 (QSPI_SS), U26.1 (~CS)
/SWCLK: U25.33 (SWCLK)
/SWD: U25.34 (SWDIO)
/VREG_AVDD: C13.1, R65.2, U25.61 (VREG_AVDD)
/VREG_LX: L1.2, U25.63 (VREG_LX)
/XIN: C16.1, U25.30 (XIN), Y1.1
/XOUT: C17.1, U25.31 (XOUT), Y1.3
/back_1_1: D47.1 (K), R104.1, U19.5 (+)
/back_1_2: D48.1 (K), R105.1, U19.3 (+)
/back_2_1: D49.1 (K), R106.1, U22.5 (+)
/back_2_2: D50.1 (K), R107.1, U22.3 (+)
/left_1_1: D41.1 (K), R98.1, U18.3 (+)
/left_1_2: D42.1 (K), R99.1, U18.5 (+)
/left_2_1: D43.1 (K), R100.1, U21.3 (+)
/left_2_2: D44.1 (K), R101.1, U21.5 (+)
/right_1_1: D35.1 (K), R92.1, U17.5 (+)
/right_1_2: D36.1 (K), R93.1, U17.3 (+)
/right_2_1: D37.1 (K), R94.1, U20.5 (+)
/right_2_2: D38.1 (K), R95.1, U20.3 (+)
BRIGHTNESS: R87.2, U25.28 (GPIO27)
DEBUG_LED: R70.1, U25.25 (GPIO24)
DEFAULT_LED: R69.1, U25.26 (GPIO25)
GND: C1.2, C2.2, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, D33.1 (K), D34.1 (K), J1.2, LINE1.A1, LINE1.A1_B12 (GND), LINE1.A12, LINE1.B1, LINE1.B1_A12 (GND), LINE1.B12, LINE1.S1 (SHIELD), LINE1.S2 (SHIELD), LINE1.S3 (SHIELD), LINE1.S4 (SHIELD), Q1.2 (S), R1.2, R2.2, R3.2, R4.2, R5.2, R6.2, R7.2, R8.2, R9.2, R10.2, R11.2, R12.2, R13.2, R14.2, R15.2, R16.2, R17.2, R18.2, R19.2, R20.2, R21.2, R22.2, R23.2, R24.2, R25.2, R26.2, R27.2, R28.2, R29.2, R30.2, R31.2, R32.2, R88.1, R90.2, R91.2, R92.2, R93.2, R94.2, R95.2, R98.2, R99.2, R100.2, R101.2, R104.2, R105.2, R106.2, R107.2, U1.4 (V-), U2.4 (V-), U3.4 (V-), U4.4 (V-), U5.4 (V-), U6.4 (V-), U7.4 (V-), U8.4 (V-), U9.4 (V-), U10.4 (V-), U11.4 (V-), U12.4 (V-), U13.4 (V-), U14.4 (V-), U15.4 (V-), U16.4 (V-), U17.4 (V-), U18.4 (V-), U19.4 (V-), U20.4 (V-), U21.4 (V-), U22.4 (V-), U25.62 (VREG_PGND), U25.81 (GND), U26.4 (GND), Y1.2, Y1.4
Line_D0: R34.1, U1.7, U25.17 (GPIO17)
Line_D1: R33.1, U1.1, U25.16 (GPIO16)
Line_D2: R36.1, U2.7, U25.14 (GPIO15)
Line_D3: R35.1, U2.1, U25.13 (GPIO14)
Line_D4: R38.1, U3.7, U25.12 (GPIO13)
Line_D5: R37.1, U3.1, U25.11 (GPIO12)
Line_D6: R40.1, U4.7, U25.9 (GPIO11)
Line_D7: R39.1, U4.1, U25.8 (GPIO10)
Line_D8: R42.1, U5.7, U25.3 (GPIO6)
Line_D9: R41.1, U5.1, U25.80 (GPIO3)
Line_D10: R44.1, U6.7, U25.79 (GPIO2)
Line_D11: R43.1, U6.1, U25.78 (GPIO1)
Line_D12: R46.1, U7.7, U25.58 (GPIO47_ADC7)
Line_D13: R45.1, U7.1, U25.57 (GPIO46_ADC6)
Line_D14: R48.1, U8.7, U25.56 (GPIO45_ADC5)
Line_D15: R47.1, U8.1, U25.55 (GPIO44_ADC4)
Line_D16: R50.1, U9.7, U25.54 (GPIO43_ADC3)
Line_D17: R49.1, U9.1, U25.48 (GPIO39)
Line_D18: R52.1, U10.7, U25.47 (GPIO38)
Line_D19: R51.1, U10.1, U25.46 (GPIO37)
Line_D20: R54.1, U11.7, U25.45 (GPIO36)
Line_D21: R53.1, U11.1, U25.44 (GPIO35)
Line_D22: R56.1, U12.7, U25.43 (GPIO34)
Line_D23: R55.1, U12.1, U25.42 (GPIO33)
Line_D24: R58.1, U13.7, U25.37 (GPIO29)
Line_D25: R57.1, U13.1, U25.36 (GPIO28)
Line_D26: R60.1, U14.7, U25.23 (GPIO23)
Line_D27: R59.1, U14.1, U25.22 (GPIO22)
Line_D28: R62.1, U15.7, U25.21 (GPIO21)
Line_D29: R61.1, U15.1, U25.20 (GPIO20)
Line_D30: R64.1, U16.7, U25.19 (GPIO19)
Line_D31: R63.1, U16.1, U25.18 (GPIO18)
MCU_RUN: U25.35 (RUN), line_1.6
unnamed: D33.2 (A), R69.2
unnamed: D34.2 (A), R70.2
unnamed: D53.2 (A), R110.1, U17.1
unnamed: D54.2 (A), R111.1, U18.1
unnamed: D55.2 (A), R112.1, U19.1
unnamed: D56.2 (A), R113.1, U17.7
unnamed: D57.2 (A), R114.1, U18.7
unnamed: D58.2 (A), R115.1, U19.7
unnamed: D59.2 (A), R116.1, U20.1
unnamed: D60.2 (A), R117.1, U21.1
unnamed: D61.2 (A), R118.1, U22.1
unnamed: D62.2 (A), R119.1, U20.7
unnamed: D63.2 (A), R120.1, U21.7
unnamed: D64.2 (A), R121.1, U22.7
unnamed: LED_1.2 (A), LED_2.2 (A), R71.2
unnamed: LED_3.2 (A), LED_4.2 (A), R72.2
unnamed: LED_5.2 (A), LED_6.2 (A), R73.2
unnamed: LED_7.2 (A), LED_8.2 (A), R74.2
unnamed: LED_9.2 (A), LED_10.2 (A), R75.2
unnamed: LED_11.2 (A), LED_12.2 (A), R76.2
unnamed: LED_13.2 (A), LED_14.2 (A), R77.2
unnamed: LED_15.2 (A), LED_16.2 (A), R78.2
unnamed: LED_17.2 (A), LED_18.2 (A), R79.2
unnamed: LED_19.2 (A), LED_20.2 (A), R80.2
unnamed: LED_21.2 (A), LED_22.2 (A), R81.2
unnamed: LED_23.2 (A), LED_24.2 (A), R82.2
unnamed: LED_25.2 (A), LED_26.2 (A), R83.2
unnamed: LED_27.2 (A), LED_28.2 (A), R84.2
unnamed: LED_29.2 (A), LED_30.2 (A), R85.2
unnamed: LED_31.2 (A), LED_32.2 (A), R86.2
unnamed: LED_33.2 (A), LED_34.2 (A), R128.2
unnamed: LED_35.2 (A), LED_36.2 (A), R129.2
unnamed: LED_39.2 (A), LED_40.2 (A), R131.2
unnamed: LED_41.2 (A), LED_42.2 (A), R132.2
unnamed: LED_45.2 (A), LED_46.2 (A), R134.2
unnamed: LED_47.2 (A), LED_48.2 (A), R135.2
unnamed: LINE1.A5 (CC1), R91.1
unnamed: LINE1.B5 (CC2), R90.1
unnamed: Q1.1 (G), R87.1, R88.2
unnamed: R67.1, U25.66 (USB_DM)
unnamed: R66.1, U25.67 (USB_DP)
PWM: C20.1, R89.2, U1.2 (-), U1.6 (-), U2.2 (-), U2.6 (-), U3.2 (-), U3.6 (-), U4.2 (-), U4.6 (-), U5.2 (-), U5.6 (-), U6.2 (-), U6.6 (-), U7.2 (-), U7.6 (-), U8.2 (-), U8.6 (-), U9.2 (-), U9.6 (-), U10.2 (-), U10.6 (-), U11.2 (-), U11.6 (-), U12.2 (-), U12.6 (-), U13.2 (-), U13.6 (-), U14.2 (-), U14.6 (-), U15.2 (-), U15.6 (-), U16.2 (-), U16.6 (-), U17.2 (-), U17.6 (-), U18.2 (-), U18.6 (-), U19.2 (-), U19.6 (-), U20.2 (-), U20.6 (-), U21.2 (-), U21.6 (-), U22.2 (-), U22.6 (-)
PWM_main: R89.1, U25.27 (GPIO26)
USB_BOOT: R68.1, line_1.5
conn: LED_1.1 (K), LED_2.1 (K), LED_3.1 (K), LED_4.1 (K), LED_5.1 (K), LED_6.1 (K), LED_7.1 (K), LED_8.1 (K), LED_9.1 (K), LED_10.1 (K), LED_11.1 (K), LED_12.1 (K), LED_13.1 (K), LED_14.1 (K), LED_15.1 (K), LED_16.1 (K), LED_17.1 (K), LED_18.1 (K), LED_19.1 (K), LED_20.1 (K), LED_21.1 (K), LED_22.1 (K), LED_23.1 (K), LED_24.1 (K), LED_25.1 (K), LED_26.1 (K), LED_27.1 (K), LED_28.1 (K), LED_29.1 (K), LED_30.1 (K), LED_31.1 (K), LED_32.1 (K), LED_33.1 (K), LED_34.1 (K), LED_35.1 (K), LED_36.1 (K), LED_39.1 (K), LED_40.1 (K), LED_41.1 (K), LED_42.1 (K), LED_45.1 (K), LED_46.1 (K), LED_47.1 (K), LED_48.1 (K), Q1.3 (D)
line_D+: LINE1.A6 (DP1), LINE1.B6 (DP2), R66.2, line_1.3
line_D-: LINE1.A7 (DN1), LINE1.B7 (DN2), R67.2, line_1.4
mainRX1→lineTX: U25.1 (GPIO4), line_1.2
mainTX1→lineRX: U25.2 (GPIO5), line_1.1
subLine_back1: D55.1 (K), D58.1 (K), U25.49 (GPIO40_ADC0)
subLine_back2: D61.1 (K), D64.1 (K), U25.52 (GPIO41_ADC1)
subLine_back3: U25.53 (GPIO42_ADC2)
subLine_left1: D54.1 (K), D57.1 (K), U25.40 (GPIO32)
subLine_left2: D60.1 (K), D63.1 (K), U25.39 (GPIO31)
subLine_left3: U25.38 (GPIO30)
subLine_right1: D53.1 (K), D56.1 (K), U25.7 (GPIO9)
subLine_right2: D59.1 (K), D62.1 (K), U25.6 (GPIO8)
subLine_right3: U25.4 (GPIO7)

Notes on the sheet:
side LED
FLASH
DEBUG
抵抗はMCU近く
CRYSTAL
side photo
LINE_SENSOR
Angel Comparator
POWER_ON
ABM8-272-T3
Angel Sensor
side comp
MCU RP2350
LINE TYPE-C
Angel LED

Board: 2 copper layers, 196.0 x 158.0 mm, 272 parts (90 on the bottom side), 147 nets.

File Circuit/WorldChampionship/line_RP2350/production/bom.csv:

Designator,Footprint,Quantity,Value,LCSC Part #
"C1, C10, C11, C12, C18, C3, C4, C5, C6, C7, C8, C9",0402,12,0.1,
C13,0402,1,4.7,C1872
"C14, C15, C2",0402,3,4.7,
"C16, C17",0402,2,15p,C1548
C19,CP_Elec_5x5.4,1,100,
C20,C_Elec_4x5.4,1,1u,C3348
"D1, D10, D11, D12, D13, D14, D15, D16, D17, D18, D19, D2, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D3, D30, D31, D32, D35, D36, D37, D38, D4, D41, D42, D43, D44, D47, D48, D49, D5, D50, D6, D7, D8, D9",0603,44,NJL,
D33,0603,1,BLUE,
D34,0603,1,GREEN,
"D53, D54, D55, D56, D57, D58, D59, D60, D61, D62, D63, D64",D_SOD-323,12,SBD,
J1,JST_XH_S2B-XH-A_1x02_P2.50mm_Horizontal,1,Conn_01x02_Socket,
L1,Inductor_0806_2016,1,3.3,C42411119
"LED_1, LED_10, LED_11, LED_12, LED_13, LED_14, LED_15, LED_16, LED_17, LED_18, LED_19, LED_2, LED_20, LED_21, LED_22, LED_23, LED_24, LED_25, LED_26, LED_27, LED_28, LED_29, LED_3, LED_30, LED_31, LED_32, LED_33, LED_34, LED_35, LED_36, LED_39, LED_4, LED_40, LED_41, LED_42, LED_45, LED_46, LED_47, LED_48, LED_5, LED_6, LED_7, LED_8, LED_9",0603,44,LED,
LINE1,USB_C_Receptacle_XKB_U262-16XN-4BVC11,1,TYPE-C_LINE,
LINE_1,TE_84952-6_1x06-1MP_P1.0mm_Horizontal,1,Conn_01x06_Socket,
Q1,SOT-23,1,AO3400A,
"R1, R10, R100, R101, R104, R105, R106, R107, R11, R12, R13, R14, R15, R16, R17, R18, R19, R2, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R3, R30, R31, R32, R4, R5, R6, R7, R8, R9, R92, R93, R94, R95, R98, R99",0603,44,69.8k,C23098
"R110, R111, R112, R113, R114, R115, R116, R117, R118, R119, R120, R121, R33, R34, R35, R36, R37, R38, R39, R40, R41, R42, R43, R44, R45, R46, R47, R48, R49, R50, R51, R52, R53, R54, R55, R56, R57, R58, R59, R60, R61, R62, R63, R64",0603,44,1k,C23098
"R128, R129, R131, R132, R134, R135, R71, R72, R73, R74, R75, R76, R77, R78, R79, R80, R81, R82, R83, R84, R85, R86",0603,22,25,
R65,0603,1,33,C177281
R66,0402,1,22,C174144
R67,0402,1,22,
R68,0402,1,1k,C174178
R69,0402,1,15,C22369173
R70,0402,1,30,C22356186
R87,0805,1,220,
R88,0603,1,10k,
R89,0603,1,10k,C23098
"R90, R91",0603,2,5.1k,C26033
"U1, U10, U11, U12, U13, U14, U15, U16, U17, U18, U19, U2, U20, U21, U22, U3, U4, U5, U6, U7, U8, U9",SOIC-8_3.9x4.9mm_P1.27mm,22,LM393,
U25,RP2350B_QFN-80_EP_10.573x10.573_Pitch0.4mm,1,RP2350B-QFN80,
U26,SOIC-8_5.23x5.23mm_P1.27mm,1,W25Q128JVS,
Y1,Crystal_SMD_3225-4Pin_3.2x2.5mm,1,Crystal_GND24,C20625731
